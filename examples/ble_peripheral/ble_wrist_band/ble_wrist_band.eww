<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\user_board\s132\iar\ble_wrist_band_112.ewp</path>
        </project>
    <batchBuild />
</workspace>